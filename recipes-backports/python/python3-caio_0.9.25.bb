SUMMARY = "caio: Asynchronous file IO for Linux MacOS or Windows."

HOMEPAGE = "https://github.com/mosquito/caio"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=5bfb72cbb53281574a4ccc9e7a5cc96f"

SRC_URI[sha256sum] = "16498e7f81d1d0f5a4c0ad3f2540e65fe25691376e0a5bd367f558067113ed10"

PYPI_PACKAGE = "caio"

inherit pypi setuptools3
